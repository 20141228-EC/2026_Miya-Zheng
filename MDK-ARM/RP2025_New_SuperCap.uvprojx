# Keil uVision project RP2025_New_SuperCap.uvprojx, settings and files
target RP2025_New_SuperCap (6240000::V6.24::ARMCLANG)
  device: STM32G474CETx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.4.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: RP2025_New_SuperCap +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32G474xx,__TARGET_FPU_VFP,__FPU_PRESENT=1U
  c include: ../Core/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../Drivers/CMSIS/Include;../Application/AlgorithmLayer;../Application/ConfigLayer;../Application/DebugLayer;../Application/DeviceLayer;../Application/DriverLayer;../Application/ProtocolLayer
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application/MDK-ARM
    ./: startup_stm32g474xx.s
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal_adc.c stm32g4xx_hal_adc_ex.c stm32g4xx_ll_adc.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal_fdcan.c stm32g4xx_hal_hrtim.c stm32g4xx_hal_opamp.c stm32g4xx_hal_opamp_ex.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g4xx.c
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c dma.c fdcan.c hrtim.c opamp.c stm32g4xx_it.c stm32g4xx_hal_msp.c stm32g4xx_hal_timebase_tim.c
  group Driver
    ../Application/DriverLayer/: drv_adc.c drv_adc.h drv_hrtim.c drv_hrtim.h drv_can.c drv_can.h drv_opamp.c drv_opamp.h driver.c driver.h
  group Protocol
    ../Application/ProtocolLayer/: can_protocol.c
  group Device
    ../Application/DeviceLayer/: cap_board.c cap_board.h cap_board_config.h
  group Algorithm
    ../Application/AlgorithmLayer/: pid.c my_math.c
  group Config
    ../Application/ConfigLayer/: config.h
  group Debug
    ../Application/DebugLayer/: DWT.c DWT.h WL_debug_uart.c WL_debug_uart.h stm32g4xx_hal_uart.c stm32g4xx_hal_uart.h stm32g4xx_hal_uart_ex.c stm32g4xx_hal_uart_ex.h
software components: CMSIS:CORE 5.6.0, CMSIS:DSP 1.16.2
